Commit message: update

File: robotshyu/robots/NRMK/indy7/indy7_description/indy7_floating.urdf (robot description, URDF)
Before this commit: robot indy7_floating, 9 links, 8 joints
Links:
- link tcp: mass 0.000001 -> 0
- link world: mass 0.000001 -> 0
